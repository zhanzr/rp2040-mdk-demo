# Keil uVision project rp2040_example.uvprojx, settings and files
target Pico (6240000::V6.24::ARMCLANG)
  device: RP2040:Core0 RPi
  pack: RaspberryPi.RP2xxx_DFP.0.9.5
  cpu: IRAM(0x20000000,0x00042000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rp2040_example
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\User;.
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x42000
  scatter file: .\scatter\core0.sct
  group APP
    ./User/: main.c utils.c
  group scatter
    ./scatter/: core0.sct
  group doc
    ./: README.md
  group ws2812
    ./: ws2812.pio
software components: CMSIS-Compiler:CORE 1.2.1, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.2.0, Device:Pico Board 1.5.1, Device:Pico SDK 1.5.1, Device:Startup 1.1.0
